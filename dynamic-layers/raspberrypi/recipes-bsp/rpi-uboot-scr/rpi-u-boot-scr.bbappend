FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

COMPATIBLE = "raspberrypi3 raspberrypi4 raspberrypi4-64 raspberrypi5 raspberrypi-cm5-io-board"
